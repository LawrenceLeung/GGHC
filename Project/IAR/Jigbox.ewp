# IAR project Jigbox.ewp, settings and files
configuration Olmx flash debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxG ST STM32F10xxG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ; app\; module\; ..\library\inc; ..\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\CMSIS\CM3\CoreSupport\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: AudioDevice.out
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Dscvr 103RB flash debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_MD_VL; STM_DISCOVERY
  ICCARM.CCIncludePath2: ; app\; board\; module\; ..\library\inc; ..\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\CMSIS\CM3\CoreSupport\
configuration Dscvr 103RG flash debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EMB_FLASH
  ICCARM.CCIncludePath2: ; app\; board\; module\; ..\library\inc
  group (top)
    app/: audio.c audio.h audio_class.c DDS.c LED.c main.c system_stm32f10x.c systick.c
  group Other
    ../: README.txt
  group STM32F10xFWLib
    ../library/src/: misc.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c
  group Vectors
    app/: stm32f10x_it.c
